# IAR project Semihost.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC1262AE series Nuvoton NUC1262AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; DEBUG_ENABLE_SEMIHOST=1
  ICCARM.CCIncludePath2: ..\..\..\Library\CMSIS\Include; ..\..\..\Library\Device\Nuvoton\NUC1262\Include; ..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG_ENABLE_SEMIHOST
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: Semihost.bin
  ILINK.IlinkOutputFile: Semihost.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/NUC1262/Source/IAR/: startup_NUC1262.s
    ../../../Library/Device/Nuvoton/NUC1262/Source/: system_NUC1262.c
  group Library
    ../../../Library/StdDriver/src/: retarget.c
  group User
    ../: main.c
