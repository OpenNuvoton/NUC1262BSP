# IAR project fmc_ap_main.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC1262AE series Nuvoton NUC1262AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC1262\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: fmc_ap_main.bin
  ILINK.IlinkOutputFile: APROM_code.out
  ILINK.IlinkIcfFile: fmc_ap_main.icf
  ILINK.IlinkExtraOptions: --image_input Release\Exe\fmc_ld_iap.bin,loaderImage1Base,.bin_image,4; --image_input Release\Exe\fmc_ld_iap.bin,loaderImage1Limit,.bin_image,4
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1262/Source/IAR/: startup_NUC1262.s
    ../../../../Library/Device/Nuvoton/NUC1262/Source/: system_NUC1262.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group User
    ../: aprom_main.c
