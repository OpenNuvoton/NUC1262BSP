# Keil uVision project BPWM_DoubleBuffer_PeriodLoadingMode.uvprojx, settings and files
target BPWM_DoubleBuffer_PeriodLoadingMode (6120000::V6.12::.\ARMCLANG)
  device: NUC1262SE4AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.11
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: BPWM_DoubleBuffer_PeriodLoadingMode
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC1262\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC1262.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1262/Source/ARM/: startup_NUC1262.S
    ../../../../Library/Device/Nuvoton/NUC1262/Source/: system_NUC1262.c
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c bpwm.c sys.c uart.c
