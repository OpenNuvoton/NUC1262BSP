# IAR project LLSI_Y_Cable_Control.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: NUC1262AE series Nuvoton NUC1262AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082, Pe144, Pe188, Pe513, Pe550
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC1262\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\LlsiYcableLib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LLSI_Y_Cable_Control.bin
  ILINK.IlinkOutputFile: LLSI_Y_Cable_Control.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC1262/Source/IAR/: startup_NUC1262.s
    ../../../../Library/Device/Nuvoton/NUC1262/Source/: system_NUC1262.c
  group Library
    ../../../../Library/StdDriver/src/: bpwm.c clk.c gpio.c llsi.c pdma.c retarget.c sys.c uart.c
  group LlsiYcableLib
    ../../../../Library/LlsiYcableLib/: hdiv.c led_control.c led_gen2_control.c
  group User
    ../: main.c
